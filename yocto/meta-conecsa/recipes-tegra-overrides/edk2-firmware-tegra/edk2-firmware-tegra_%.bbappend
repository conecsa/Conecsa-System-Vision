# SRCREV 30419afc4a6ea666434f9275057f579b46a07a5f no longer exists on the
# r36.5-updates branch of NVIDIA/edk2. Bumps to the current HEAD,
# confirmed via git ls-remote on 2026-05-16.
SRCREV_edk2 = "3dfcdaec4a6e49fb74c801137256bf3c9560bf18"
