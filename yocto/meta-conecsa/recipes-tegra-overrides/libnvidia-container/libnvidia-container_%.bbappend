# SRCREV 921e2f3197385173cf8670342e96e98afe9b3dd3 pinned by the meta-tegra
# scarthgap recipe no longer exists on the upstream main branch
# (NVIDIA/libnvidia-container). Bumps to the current HEAD, confirmed via
# git ls-remote on 2026-05-16.
SRCREV:pn-libnvidia-container = "bc447b147df52d3eea4b1880e9871985c9bef3b7"
